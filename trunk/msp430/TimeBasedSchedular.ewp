# IAR project TimeBasedSchedular.ewp, settings and files
configuration Debug (MSP430, debug)
  General.GHeapSize: 1100
  General.GStackSize: 80
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\; $PROJ_DIR$
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group App
    application/: ECG_Filter.s43 PeakDetection.c
  group Command
    Command/: Command.c LT1.c LT2.c LT3.c LT4.c LT5.c
  group System
    System/: ADCManager.c CooperSchedular.c ErrorReport.c Fat16.c mmc.c RTC.c TBManager.c
  group System/IO
    System/IO/: PortManager.c UART.c
  group System/ITC
    System/ITC/: Pipe.c Signal.c
