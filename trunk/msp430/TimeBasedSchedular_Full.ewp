# IAR project TimeBasedSchedular_Full.ewp, settings and files
configuration Debug (MSP430, debug)
  General.GHeapSize: 1000
  General.GStackSize: 80
  ICC430.newCCIncludePaths: $PROJ_DIR$
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group Application
    application/: PeakDetection.c UserInterface.c
  group Command
    Command/: Command.c LT1.c LT2.c LT3.c LT4.c LT5.c
  group Device
    dev/: OLED.C
  group System
    System/: ADCManager.c ErrorReport.c RTC.c TBManager.c
  group System/IO
    System/IO/: PortManager.c UART.c
  group System/IPC
    System/IPC/: RangBuffer.c Signal.c
  group System/Scheduler
    System/Scheduler/: CooperSchedular.c
